## config/boards/shields/stine_artsey/Kconfig.defconfig
```kconfig
if SHIELD_STINE_ARTSEY

    config ZMK_KEYBOARD_NAME
        default "STINE-ARTSEY"

endif
```
